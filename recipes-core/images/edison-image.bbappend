# Adds some useful utilities to the standard Intel Edison build

IMAGE_INSTALL += "bison"
IMAGE_INSTALL += "coreutils"
IMAGE_INSTALL += "git"

IMAGE_INSTALL += "nano"
IMAGE_INSTALL += "packagegroup-core-qt4e"
IMAGE_INSTALL += "cmake"

